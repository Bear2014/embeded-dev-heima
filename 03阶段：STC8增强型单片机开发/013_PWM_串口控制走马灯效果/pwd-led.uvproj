# Keil uVision project pwd-led.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: pwd-led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./lib/: Config.h STC8G_H_Delay.h STC8G_H_GPIO.c STC8G_H_GPIO.h STC8G_H_NVIC.c STC8G_H_NVIC.h STC8G_H_Switch.h STC8H_PWM.c STC8H_PWM.h STC8G_H_Delay.c STC8G_H_UART.c STC8G_H_UART_Isr.c
